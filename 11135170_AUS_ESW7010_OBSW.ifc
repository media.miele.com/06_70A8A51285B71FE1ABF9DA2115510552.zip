Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable], RevitIdentifiers [VersionGUID: 37c75e46-a84a-4ac0-8b1d-40c852334fd1, NumberOfSaves: 1]
File name: 0001
Time: 2026-09-11T16:09:52+01:00
Written by: ODA SDAI 23.12
Made in: Autodesk Revit 24.0.20.20 (ENU) - IFC 24.0.20.20

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 11135170_AUS_ESW7010_OBSW:30701020_AUS_11135170_ESW7010_OBSW, (2)
In: Default
Type - Material: z_Miele_Design_OBSW, z_Miele_Design_Zinc_Steel, z_Miele_Connection_Electric
Type - Pset_ManufacturerTypeInformation - Manufacturer: Miele
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_ProvisionForVoid - Width: 595 mm; Height: 141 mm; Depth: 570 mm
Classification: E1090320 Uniformat (Uniformat)
Pset_BuildingElementProxyCommon - Reference: 30701020_AUS_11135170_ESW7010_OBSW; sets with these values: 2
